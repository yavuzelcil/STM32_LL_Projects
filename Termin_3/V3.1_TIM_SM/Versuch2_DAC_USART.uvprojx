# Keil uVision project Versuch2_DAC_USART.uvprojx, settings and files
target STM32F446RE_NUCLEO (6190000::V6.19::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Versuch2_DAC_USART
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./: main.c USART2.c USART2.h DAC.c DAC.h main.h Stepper.c TIM3_PWM.c Stepper.h TIM3_PWM.h
software components: CMSIS:CORE 5.6.0, Device:STM32Cube LL:ADC 1.7.13, Device:STM32Cube LL:Common 1.7.13, Device:STM32Cube LL:DAC 1.7.13, Device:STM32Cube LL:GPIO 1.7.13, Device:STM32Cube LL:PWR 1.7.13, Device:STM32Cube LL:RCC 1.7.13, Device:STM32Cube LL:TIM 1.7.13, Device:STM32Cube LL:USART 1.7.13, Device:STM32Cube LL:UTILS 1.7.13, Device:Startup 2.6.3
