# Keil uVision project V4.1_I2C.uvprojx, settings and files
target STM32F446RE (6190000::V6.19::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: V4.1_I2C
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./: main.c main.h LCDInit.o Temperatur.c Temperatur.h I2C.c I2C.h LCD.c LCD.h USART2.c USART2.h Stepper.c Stepper.h ESP_USART3.c ESP_USART3.h TIM3_PWM.c TIM3_PWM.h
software components: CMSIS:CORE 5.6.0, Device:STM32Cube LL:ADC 1.7.13, Device:STM32Cube LL:Common 1.7.13, Device:STM32Cube LL:DAC 1.7.13, Device:STM32Cube LL:DMA 1.7.13, Device:STM32Cube LL:GPIO 1.7.13, Device:STM32Cube LL:I2C 1.7.13, Device:STM32Cube LL:PWR 1.7.13, Device:STM32Cube LL:RCC 1.7.13, Device:STM32Cube LL:RNG 1.7.13, Device:STM32Cube LL:SPI 1.7.13, Device:STM32Cube LL:TIM 1.7.13, Device:STM32Cube LL:USART 1.7.13, Device:Startup 2.6.3
